# Keil uVision project ADC0804.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT80C51RD2 Microchip
  cpu: IRAM(0x00 - 0xFF) XRAM(0x00 - 0x3FF) CLOCK(40000000) MODP2
  output: ADC0804 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Bai_11_ADC0804
  group New Group
    ./: ADC0804.c Thu_Vien_LCD.c
